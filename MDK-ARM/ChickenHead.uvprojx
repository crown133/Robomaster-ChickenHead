# Keil uVision project ChickenHead.uvprojx, settings and files
target ChickenHead (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ChickenHead +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_LL_DRIVER,USE_HAL_DRIVER,STM32F427xx,ARM_MATH_CM4,__FPU_PRESENT=1, __CC_ARM
  c include: ..\APP\Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\System\delay;..\APP\ADRC;..\APP\AHRS;..\System\sys;..\APP\Referee
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../startup/: startup_stm32f427xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_spi.c
  group CMSIS
    ../Drivers/CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group APP
    ../APP/Src/: main.c Can_Ctrl.c Control_Loop.c DataScope_DP.C Motor_Ctrl.c Remote_Ctrl.c Shoot_Ctrl.c imu.c ins.c Pc_Uart.c
    ../APP/ADRC/: adrc.c ESO.h TD4.h kalman_Filter.h
    ../APP/Referee/: Referee_Comm.c CRC.c
  group SYSTEM
    ../System/sys/: sys.c
    ../System/delay/: delay.c
  group HARDWARE
    ../APP/Src/: can.c dma.c gpio.c tim.c usart.c spi.c
  group AHRS
    ../APP/AHRS/: AHRS_middleware.c ist8310driver.c ist8310driver_middleware.c mpu6500driver.c mpu6500driver_middleware.c AHRS.lib
software components: CMSIS:CORE 4.3.0
